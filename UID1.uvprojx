# Keil uVision project UID1.uvprojx, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031G4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UID1_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__CC_ARM
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SourceFiles
    ./: main.c UID_Buttons.c UID_Protocol.c UID_RGBDriverPCA9955.c doxygen_mainpage.c additions.c
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031G4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: UID1_Release +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__CC_ARM
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.0.2, Device:Startup 2.2.3
